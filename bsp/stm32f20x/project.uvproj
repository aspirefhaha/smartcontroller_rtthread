# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\finsh;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\include\netif;Libraries\STM32F2x7_ETH_Driver\inc;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Drivers;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;Libraries\STM32F2xx_StdPeriph_Driver\inc;applications;..\..\components\rtgui\include;..\..\components\dfs\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: testrtgui.c demo_view_benchmark.c demo_view.c demo_view_button.c demo_view_label.c demo_view_window.c appmgr.c apps_list.c block_panel.c statusbar.c program.c
  group Drivers
    Drivers/: 24LCxx.c FM25Lx.c board.c i2c.c rtc.c serial.c stm32f2xx_it.c usart.c
    ./Drivers/: stm32f2_eth.c
    ./Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
    ./Drivers/LCD/: AsciiLib.c LCD.c
    ./Drivers/TouchPanel/: TouchPanel.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group rtgui
    ../../components/rtgui/common/: asc12font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_fnt.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_xpm.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c font_bmp.c font_hz_bmp.c
    ../../components/rtgui/server/: driver.c mouse.c server.c topwin.c
    ../../components/rtgui/widgets/: box.c button.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c widget.c window.c
  group lwip
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
