# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC17xx (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc +hex
  c flags: Optim=1
  c include: .;..\..\components\finsh;..\..\components\rtgui\include;..\..\components\dfs\include;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;CMSIS\CM3\CoreSupport;CMSIS\CM3\DeviceSupport\NXP\LPC177x_8x;applications;drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c
    ./applications/: startup.c httpclient.c sc_ping.c sh_app.c cJSON.c
  group CMSIS
    CMSIS/CM3/CoreSupport/: core_cm3.c
    CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group Drivers
    drivers/: board.c drv_glcd.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc17xx_lcd.c sdram.c uart.c
    ./drivers/: emac.c lpc177x_8x_mci.c lpc177x_8x_gpdma.c touchpanel.c lpc177x_8x_adc.c lpc177x_8x_gpio.c led.c putchar.c fs_mci.c lpc177x_8x_rtc.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rtgui
    ../../components/rtgui/server/: driver.c mouse.c server.c topwin.c
    ../../components/rtgui/widgets/: button.c label.c panel.c window.c widget.c container.c box.c notebook.c title.c staticline.c
    ../../components/rtgui/common/: hz12font.c pixel_driver.c rtgui_app.c rtgui_object.c rtgui_system.c image.c image_container.c region.c rtgui_theme.c dc.c dc_buffer.c dc_hw.c framebuffer_driver.c color.c blit.c dc_client.c font_hz_bmp.c font.c filerw.c asc16font.c hz16font.c image_hdc.c font_bmp.c font_hz_file.c font_freetype.c image_bmp.c font_fnt.c asc12font.c
  group gui_example
    ./gui_example/: block_panel.c demo_view.c demo_view_benchmark.c demo_view_button.c demo_view_label.c demo_view_window.c testrtgui.c
  group lwip
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: cc936.c
  group test_xml
    ./test_xml/: config_init.c mcbxml.c netcnf.c main_win.c
